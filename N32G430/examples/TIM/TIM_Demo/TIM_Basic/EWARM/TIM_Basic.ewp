# IAR project TIM_Basic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G430C8 Nations N32G430C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G430; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\CMSIS\device\startup; ..\..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc; ..\..\..\TIM_Src; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_DMA.srec
  ILINK.IlinkOutputFile: TIM_Basic.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_dbg.c n32g430_dma.c n32g430_gpio.c n32g430_rcc.c n32g430_tim.c n32g430_usart.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g430_EWARM.s
  group TIM_Basic
    ../: main.c
  group TIM_Src
    ../../../TIM_Src/: ADTIM_common.c BSTIM_common.c GPTIM_common.c ISR_common.c timer_common.c
