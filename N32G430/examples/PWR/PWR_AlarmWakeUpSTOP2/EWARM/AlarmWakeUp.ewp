# IAR project AlarmWakeUp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G430C8 Nations N32G430C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G430; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc; ..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AlarmWakeUp.bin
  ILINK.IlinkOutputFile: AlarmWakeUp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G430\N32G430x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group DOC
    ../: readme.txt
  group FWLIB
    ../../../../../../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g430_EWARM.s
  group USER
    ../src/: delay.c main.c n32g430_it.c
