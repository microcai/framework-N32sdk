# IAR project IWDG_Reset.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G430C8 Nations N32G430C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G430; USE_STDPERIPH_DRIVER; LSI_TIM_MEASURE
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IWDG_Reset.bin
  ILINK.IlinkOutputFile: BEEPER_Output.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_dbg.c n32g430_gpio.c n32g430_iwdg.c n32g430_rcc.c n32g430_tim.c n32g430_usart.c
  group LOG
    ../src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g430_EWARM.s
  group USER
    ../src/: bsp_delay.c bsp_led.c main.c n32g430_it.c
