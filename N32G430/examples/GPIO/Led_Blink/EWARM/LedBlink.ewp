# IAR project LedBlink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G430C8 Nations N32G430C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G430; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LedBlink.bin
  ILINK.IlinkOutputFile: LedBlink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group DELAY
    ../src/: bsp_delay.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g430_std_periph_driver/src/: n32g430_gpio.c n32g430_rcc.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g430_EWARM.s
  group USER
    ../src/: bsp_led.c main.c n32g430_it.c
